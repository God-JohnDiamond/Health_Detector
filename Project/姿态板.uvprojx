# Keil uVision project 姿态板.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 姿态板 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\Lib\inc;..\User;..\User\eMPL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group Lib
    ../Lib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
  group User
    ../User/: main.c delay.c stm32f10x_it.c usart.c stm32_iic.c iic.c LCD.c Time.c adc.c
  group eMPL
    ../User/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
software components: CMSIS:CORE 4.3.0
